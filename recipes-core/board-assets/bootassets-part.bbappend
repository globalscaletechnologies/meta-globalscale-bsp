FILESEXTRAPATHS:prepend:globalscale-mt510ss-evk := "${THISDIR}/${PN}:"

