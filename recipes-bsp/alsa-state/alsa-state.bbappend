FILESEXTRAPATHS:prepend:cortadodeck := "${THISDIR}/cortadodeck:"
